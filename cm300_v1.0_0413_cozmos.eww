<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cm300_v1.0_0413_cozmos.ewp</path>
    </project>
    <batchBuild />
</workspace>
