# IAR project cm300_v1.0_0413_cozmos.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: cm300_v1.0_0413_cozmos.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group inc
    inc/: cm300.h stm8s.h stm8s_adc1.h stm8s_clk.h stm8s_conf.h stm8s_flash.h stm8s_gpio.h stm8s_it.h stm8s_tim1.h stm8s_tim2.h stm8s_tim4.h
  group src
    src/: cm300.c main.c stm8_interrupt_vector.c stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_it.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c
